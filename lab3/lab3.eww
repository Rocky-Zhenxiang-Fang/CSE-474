<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Task1a\task1_a.ewp</path>
    </project>
    <batchBuild />
</workspace>
